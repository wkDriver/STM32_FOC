# Keil uVision project STM32_PMSM_Sensorless_V17.2.uvprojx, settings and files
target STM32_PMSM_Sensorless_V17_2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_PMSM_Sensorless +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\Project;..\FWlib\inc;..\FWlib\src;..\User_include;..\User_program
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Project
    ./: main.c stm32f10x_it.c
  group User_program
    ../User_program/: GPIO_int.c Timer.c ADC_int.c Tim1_PWM.c Tim1_ISR_MCLoop.c IQ_math.c Svpwm_dq.c Axis_transform.c Tim4_Encoder_PWMDAC.c Task_function.c PI_Cale.c Usart_RS232.c Sensorless_SMO.c CAN.c
software components: CMSIS:CORE 4.1.0
